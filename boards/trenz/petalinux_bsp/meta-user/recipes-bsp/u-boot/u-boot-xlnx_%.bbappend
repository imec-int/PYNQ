FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://platform-top.h \
            file://devtool-fragment.cfg \
	    file://jesd.cfg \		
            file://user_layers.cfg \
            "
